MIRRORS += " \
    git://anongit.freedesktop.org/gstreamer/common git://gitlab.freedesktop.org/gstreamer/common.git;protocol=git;destsuffix=git/common;name=common; \
"