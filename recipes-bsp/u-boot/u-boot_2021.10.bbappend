SRC_URI = "git://git@github.com/imd-tec/renesas-u-boot-cip.git;protocol=ssh;branch=imdt-v2021.10-rzv2h"
SRCREV = "fae07fffdd794dbb20ef6b6e6b4d31c4e1c1aec9"
