# Add support for the RZ/V2N 
COMPATIBLE_MACHINE_append = "|rzv2n" 
