COMPATIBLE_MACHINE_append = "|rzv2n"
#DEPENDS_append_rzv2n = " kernel-module-vsp2driver"