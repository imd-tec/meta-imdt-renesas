# Same binaries work on the V2N
COMPATIBLE_MACHINE:append = "|rzv2n-family"
