DEFAULTBACKEND = "drm"
PACKAGECONFIG:append = " use-pixman"