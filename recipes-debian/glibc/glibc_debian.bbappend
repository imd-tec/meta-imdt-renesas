MIRRORS += " \
    ${DEBIAN_SECURITY_UPDATE_MIRROR} https://debian.sipwise.com/debian-security/pool \
"
